SUMMARY = "Bootable Linux, static BusyBox and a writable ext2 SD card"
LICENSE = "MIT"
inherit image
