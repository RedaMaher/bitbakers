do_deploy[dirs] = "${DEPLOY_DIR_IMAGE}"
addtask deploy after do_compile before do_build
